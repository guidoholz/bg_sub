## Config.in
```kconfig
config BR2_PACKAGE_OPENCV_BG_SUB
	bool "OPENCV_BG_SUB"
	select BR2_PACKAGE_OPENCV3
	help
	  opencv bg_sub

comment "a simple opencv example without GUI"
```
